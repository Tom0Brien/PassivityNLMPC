Commit message: Update 2_link.urdf

File: urdfs/2_link.urdf (robot description, URDF)
Before this commit: robot 2_link, 4 links, 3 joints
Joints:
- joint link_1: axis 0 0 1 -> 0 1 0
- joint link_2: axis 0 0 1 -> 0 1 0
